#include "oled.h"
#include "i2c_bus.h"
#include <string.h>

#define OLED_ADDR 0x3CU
#define OLED_COLUMNS 16U

/* 5x7 font for ASCII 0x20..0x5A (space, punctuation, digits, uppercase). */
static const uint8_t s_font[59][5] = {
 {0,0,0,0,0},       /* space */
 {0,0,0x5F,0,0}, {0,7,0,7,0}, {0x14,0x7F,0x14,0x7F,0x14},
 {0x24,0x2A,0x7F,0x2A,0x12}, {0x23,0x13,8,0x64,0x62},
 {0x36,0x49,0x55,0x22,0x50}, {0,5,3,0,0},
 {0,0x1C,0x22,0x41,0}, {0,0x41,0x22,0x1C,0},
 {0x14,8,0x3E,8,0x14}, {8,8,0x3E,8,8},
 {0,0x50,0x30,0,0}, {8,8,8,8,8}, {0,0x60,0x60,0,0},
 {0x20,0x10,8,4,2},
 {0x3E,0x51,0x49,0x45,0x3E}, {0,0x42,0x7F,0x40,0},
 {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31},
 {0x18,0x14,0x12,0x7F,0x10}, {0x27,0x45,0x45,0x45,0x39},
 {0x3C,0x4A,0x49,0x49,0x30}, {1,0x71,9,5,3},
 {0x36,0x49,0x49,0x49,0x36}, {6,0x49,0x49,0x29,0x1E},
 {0,0x36,0x36,0,0}, {0,0x56,0x36,0,0},
 {8,0x14,0x22,0x41,0}, {0x14,0x14,0x14,0x14,0x14},
 {0,0x41,0x22,0x14,8}, {2,1,0x51,9,6},
 {0x32,0x49,0x79,0x41,0x3E},
 {0x7E,0x11,0x11,0x11,0x7E}, {0x7F,0x49,0x49,0x49,0x36},
 {0x3E,0x41,0x41,0x41,0x22}, {0x7F,0x41,0x41,0x22,0x1C},
 {0x7F,0x49,0x49,0x49,0x41}, {0x7F,9,9,9,1},
 {0x3E,0x41,0x49,0x49,0x7A}, {0x7F,8,8,8,0x7F},
 {0,0x41,0x7F,0x41,0}, {0x20,0x40,0x41,0x3F,1},
 {0x7F,8,0x14,0x22,0x41}, {0x7F,0x40,0x40,0x40,0x40},
 {0x7F,2,0x0C,2,0x7F}, {0x7F,4,8,0x10,0x7F},
 {0x3E,0x41,0x41,0x41,0x3E}, {0x7F,9,9,9,6},
 {0x3E,0x41,0x51,0x21,0x5E}, {0x7F,9,0x19,0x29,0x46},
 {0x46,0x49,0x49,0x49,0x31}, {1,1,0x7F,1,1},
 {0x3F,0x40,0x40,0x40,0x3F}, {0x1F,0x20,0x40,0x20,0x1F},
 {0x3F,0x40,0x38,0x40,0x3F}, {0x63,0x14,8,0x14,0x63},
 {7,8,0x70,8,7}, {0x61,0x51,0x49,0x45,0x43}
};

static const uint8_t *font_for(char c)
{
    if (c >= 'a' && c <= 'z') c = (char)(c - 'a' + 'A');
    if (c < ' ' || c > 'Z') return s_font[0];
    return s_font[(uint8_t)c - 0x20U];
}

static void oled_cmd(uint8_t cmd)
{
    uint8_t packet[2]; packet[0] = 0x00U; packet[1] = cmd;
    (void)I2C1_WriteBytes(OLED_ADDR, packet, 2U);
}

void OLED_Init(void)
{
    static const uint8_t initCmds[] = {
        0xAE, 0xD5, 0x80, 0xA8, 0x3F, 0xD3, 0x00, 0x40,
        0x8D, 0x14, 0x20, 0x02, 0xA1, 0xC8, 0xDA, 0x12,
        0x81, 0x7F, 0xD9, 0xF1, 0xDB, 0x40, 0xA4, 0xA6, 0xAF
    };
    uint8_t i;
    for (i = 0U; i < sizeof(initCmds); i++) oled_cmd(initCmds[i]);
    OLED_Clear();
}

void OLED_WriteLine(uint8_t page, const char *text)
{
    uint8_t col, i;
    uint8_t packet[1U + OLED_COLUMNS * 6U];
    if (page > 7U || text == 0) return;
    oled_cmd((uint8_t)(0xB0U | page));
    oled_cmd(0x00U); /* column low = 0 */
    oled_cmd(0x10U); /* column high = 0 */
    packet[0] = 0x40U;
    col = 1U;
    for (i = 0U; i < OLED_COLUMNS; i++)
    {
        const uint8_t *glyph;
        uint8_t k;
        char c = text[i];
        if (c == '\0') c = ' ';
        glyph = font_for(c);
        for (k = 0U; k < 5U; k++) packet[col++] = glyph[k];
        packet[col++] = 0U;
    }
    (void)I2C1_WriteBytes(OLED_ADDR, packet, (uint16_t)sizeof(packet));
}

void OLED_Clear(void)
{
    uint8_t page;
    for (page = 0U; page < 8U; page++) OLED_WriteLine(page, "                ");
}
